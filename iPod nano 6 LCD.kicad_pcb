# Repository randohinn/iPod-nano-6-LCD

File README.md:

# iPod nano gen 6 LCD experiment board

> WARNING! Board still actively being developed. Use and manufacture at your own risk.

## What is it?

This board is an experimentation and testing/development platform for the Apple iPod nano gen 6 LCD panels, which are easy and cheap to source from Aliexpress or Ebay.

## Hardware overview

### Current revision - revision a - December 2020
* ICE40HX1K-TQ144 FPGA (1280 LUTs 1.2v)
* USB-C connection for power
     * Additional USB features may come someday
* A display-only connection for the iPod nano gen 6 LCD
    * Plans for touch panel support in later revisions

## Software overview

>No software currently exists, as the boards have not been manufactured yet

## License

* The hardware is licensed under the [CERN-OHL-S v2](https://ohwr.org/cern_ohl_s_v2.txt) license
* The software is licensed under the MIT license

## KiCad design iPod nano 6 LCD.kicad_pcb

Parts:
C1, C5, C6, C7, C9, C10, C12, C14, C15, C16, C28: 10u; C_0603_1608Metric
C3, C8, C11, C18, C41, C42, C45: 4.7u; C_0603_1608Metric
C13, C29, C39, C40, C43, C44, C46: 100n; C_0603_1608Metric
C17, C21, C22, C23, C24, C25, C26, C30, C31, C32, C33, C34, C35, C36, C37, C38: 1u; C_0603_1608Metric
C19, C20: 10p; C_0603_1608Metric
C27: DNP; C_0603_1608Metric
D1: PMEG4010BEA; D_SOD-323
D2: +5V; LED_0603_1608Metric
D3: +1.8V; LED_0603_1608Metric
D4, D5: +3.3v; LED_0603_1608Metric
D6: ~~800mVf; D_0603_1608Metric
D7, D8: USR; LED_0603_1608Metric
J1: Molex_503548-1220; Molex 503548-1220
J2: USB_C_Receptacle_USB2.0; USB_C_Receptacle_GT-USB-7010
L1: 22u; L_0603_1608Metric
L2, L3, L4: 2.2u; L_0603_1608Metric
L5, L6: 600; L_0603_1608Metric
R1: 5R6; R_0603_1608Metric
R2, R6, R23, R29, R31, R32, R34, R35, R36, R37, R38: 10k; R_0603_1608Metric
R3: 442k; R_0603_1608Metric
R4: 16; R_0603_1608Metric
R5, R8, R15: 8; R_0603_1608Metric
R7, R11, R13, R33: 220; R_0603_1608Metric
R9, R10, R12, R14: 47; R_0603_1608Metric
R16, R18, R19, R20: 100k; R_0603_1608Metric
R17: 200k; R_0603_1608Metric
R21: 100; R_0603_1608Metric
R22, R30: 2k2; R_0603_1608Metric
R24: 1M; R_0603_1608Metric
R25, R26: 5.1k; R_0603_1608Metric
R27, R28: 12k; R_0603_1608Metric
SW1, SW2: SW_Push; SW_Push_1P1T_NO_CK_KMR2
TP1: 1.8v; TestPoint_Pad_D1.0mm
TP2: 3.3v; TestPoint_Pad_D1.0mm
TP3: 1.2v; TestPoint_Pad_D1.0mm
U1: AP5724; TSOT-23-6
U2: ICE40HX1K-TQ144; TQFP-144_20x20mm_P0.5mm
U3, U4, U6: TLV62569DBV; SOT-23-5
U5: XTSD04GLGEAG
U7: AT25xxx; DFN-8-1EP_3x2mm_P0.5mm_EP1.75x1.45mm
U8: USBLC6-2P6; SOT-666
U9: FT232H; QFN-48-1EP_8x8mm_P0.5mm_EP6.2x6.2mm_ThermalVias
Y1: 12MHz; Crystal_SMD_Abracon_ABM8G-4Pin_3.2x2.5mm

Connections:
+1V2: C12.1, C14.1, C15.1, C17.1, C23.1, C24.1, C25.1, L4.2, R15.1, R19.1, R21.1, R22.2, R23.2, TP3.1, U2.27, U2.51, U2.92, U2.111
+1V8: C9.1, C10.1, C22.2, C32.2, C33.2, C35.2, C36.2, C37.2, D3.2 (A), J1.4, L3.2, R6.1, R17.1, TP1.1, U2.6, U2.30, U2.89, U2.100, U2.123, U2.133
+5V: C3.1, C8.1, C11.1, C16.1, C40.1, C41.1, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), R4.1, U3.1 (EN), U3.4 (VIN), U4.1 (EN), U4.4 (VIN), U6.1 (EN), U6.4 (VIN), U8.5 (VBUS), U9.40 (VREGIN)
/CFG_CS: R29.2, U7.1 (~CS), U9.16 (ADBUS3)
/ICE_CN: R9.2, U2.117
/ICE_CNBIAS: R33.1, U2.116
/ICE_CP: R10.2, U2.118
/ICE_CPBIAS: R7.1, U2.119
/ICE_CRESET: R23.1, R30.2, SW1.1, U2.66
/ICE_DN: R12.2, U2.114
/ICE_DNBIAS: R11.2, U2.115
/ICE_DONE: D8.2 (A), R22.1, U2.65, U9.19 (ADBUS6)
/ICE_DP: R14.2, U2.113
/ICE_DPBIAS: R13.1, U2.112
/ICE_SS_B: U2.71, U9.17 (ADBUS4)
/LCD_CN: J1.3, R9.1, R33.2
/LCD_CP: J1.1, R7.2, R10.1
/LCD_DN: J1.9, R11.1, R12.1
/LCD_DP: J1.7, R13.2, R14.1
/LCD_RESET: J1.8, R6.2, U2.121
/USBD_N: J2.A7 (D-), J2.B7 (D-), U8.3 (I/O2), U8.4 (I/O2), U9.6 (DM)
/USBD_P: J2.A6 (D+), J2.B6 (D+), U8.1 (I/O1), U8.6 (I/O1), U9.7 (DP)
/USR_LED: R8.1, U2.73
/VSYNC: J1.6, U2.120
GND: C1.2, C3.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.1, C22.1, C23.2, C24.2, C25.2, C26.2, C27.2, C30.2, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.2, C40.2, C41.2, C42.1, C43.2, C44.1, C45.1, C46.1, D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D7.1 (K), D8.1 (K), J1.5, J1.11, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), R1.2, R2.2, R16.2, R18.2, R20.2, R24.2, R25.2, R26.2, R28.1, SW1.2, SW2.1, U1.2, U2.5, U2.13, U2.14, U2.59, U2.69, U2.86, U2.103, U2.132, U2.140, U3.2 (GND), U4.2 (GND), U5.4, U6.2 (GND), U7.4 (GND)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
GNDPLL: C28.2, C29.2, U2.35
LED+: D1.1 (K), J1.10, U1.5
LED-: J1.12, R1.1, U1.3
LEDPWM: R2.1, U1.4
MISO: R37.2, U2.68, U5.6, U7.2 (MISO), U9.15 (ADBUS2)
MOSI: R36.2, U2.67, U5.5, U7.5 (MOSI), U9.14 (ADBUS1)
unnamed: C1.1, R34.2, SW2.2, U2.47
unnamed: C19.1, U9.1 (XCSI), Y1.1
unnamed: C20.1, U9.2 (XCSO), Y1.2
unnamed: C39.1, U9.38 (VCCCORE)
unnamed: C42.2, C44.2, L5.2, U9.12 (VCCIO), U9.24 (VCCIO), U9.46 (VCCIO)
unnamed: C43.1, U9.37 (VCCA)
unnamed: C45.2, C46.2, L6.2, U9.3 (VPHY), U9.8 (VPLL)
unnamed: D1.2 (A), L1.2, U1.1
unnamed: D2.2 (A), R4.2
unnamed: D4.2 (A), R5.2
unnamed: D5.2 (A), R15.2
unnamed: D7.2 (A), R8.2
unnamed: J2.A5 (CC1), R25.1
unnamed: J2.B5 (CC2), R26.1
unnamed: J2.S1 (SHIELD), R24.1
unnamed: L2.1, U4.3 (SW)
unnamed: L3.1, U3.3 (SW)
unnamed: L4.1, U6.3 (SW)
unnamed: R3.2, R16.1, U4.5 (FB)
unnamed: R17.2, R18.1, U3.5 (FB)
unnamed: R19.2, R20.1, U6.5 (FB)
unnamed: R27.2, U9.34 (~RESET)
unnamed: R28.2, U9.5 (REF)
unnamed: R30.1, U9.20 (ADBUS7)
unnamed: R31.2, U7.7 (~HOLD)
unnamed: R32.2, U7.3 (~WP)
SCK: R35.2, U2.70, U5.3, U7.6 (SCK), U9.13 (ADBUS0)
SD_CS: R38.2, U2.45, U5.2
VCCPLL: C28.1, C29.1, R21.2, U2.36
VPP_2V5: C27.1, D6.1 (K), U2.108

Notes on the sheet:
Power generation for backlight. Schematic kindly provided by Mike "Electric Stuff" Harrison electricstuff.co.uk
Display connector
4GB Flash module using SPI with SD Card protocol
Main power bus dc-dc's
USB -> SPI flash programmer, schematic from Greg Davill's JTAG programmer, adapted with ICEBreaker board schematic
ice40 config flash
POWER, USER, DONE LEDs (DONE has resistor elsewhere)
Display signal and bias resistors
Unused but powered IOL. Left in to be used for scope probing if needed
IOB USER pushbutton and SD Flash CS Pin
IOR USER LED
IOT LCD communications
2V5, PLL and SPI power
FPGA Housekeeping and config pins

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
Board: 2 copper layers, 119.4 x 46.2 mm, 113 parts (0 on the bottom side), 62 nets.

## Commit log

2020-12-13 Add schematic symbol for the Molex connector for the display
2020-12-20 Add USB and ATSAMD processor
2020-12-20 Add a readme
2020-12-20 Add JTAG and LCD connector and bias resistors
2020-12-21 Add the 2 crystals on board
2020-12-21 Save anotated crystal schematic
2020-12-22 Add Symbol for XTSD04GLGEAG
2020-12-23 Add Footprint for the flash
2020-12-23 Lets do some routing changes: Unroute all!
2020-12-23 Remove the ARM on board.. Going with an fpga...
2020-12-25 Connecting up the power for the ice40 FPGA I decided to go with.
2020-12-25 Add config SPI and silkscreen for lcd
2020-12-31 Add LCD differential pairs, user led and reset/user butons, connect SD module CS pin to FPGA
2021-01-01 Nearly done with routing.
2021-01-01 SPI line pullups
2021-01-01 Debounce cap for user switch
2021-01-01 Start schematic cleanup
2021-01-04 Adjust pin mapping a bit.
